# Keil uVision project 51_DHT21.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0 - 0xFF) XRAM(0- 0xFF) IROM(0 - 0x1FFF) CLOCK(25000000)
  output: 51_DHT11 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 51_DHT21.c nRF24L01.c lcd.c DHT11.c
