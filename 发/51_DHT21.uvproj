# Keil uVision project 51_DHT21.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 51_DHT11 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\51_DHT11 - 副本
  asm include: ..\51_DHT11 - 副本
  group Source Group 1
    ./: 51_DHT21.c def.h DHT11.c
    ./nRF24L01/: nRF24L01.c
